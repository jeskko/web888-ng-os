# SPDX-License-Identifier: GPL-3.0-or-later
# fw_printenv/fw_setenv from libubootenv (as web888-setup uses), not the
# older u-boot-fw-utils
RAUC_BOOTLOADER_RDEPENDS = "libubootenv-bin"
