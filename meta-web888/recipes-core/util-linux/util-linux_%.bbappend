# SPDX-License-Identifier: GPL-3.0-or-later
CVE_STATUS[CVE-2026-53613] = "not-applicable-config: needs an fstab entry with the user or users option (restricted non-root mount); the image's fstab has none, and it has no login users but root"
