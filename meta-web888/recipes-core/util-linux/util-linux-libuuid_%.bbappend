# SPDX-License-Identifier: GPL-3.0-or-later
CVE_STATUS[CVE-2026-53613] = "not-applicable-config: a mount(8) flaw; this recipe builds only libuuid"
